# Keil uVision project B1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: B1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT=1
  c include: .\src;.\lib1;.\lib2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./src/: main.c
  group lib1
    ./lib1/: TIMER.c TIMER.h ADC.c ADC.h UART.c UART.h SYSTICK.h SYSTICK.c I2S.c I2S.h SPI.h SPI.c
  group lib2
    ./lib2/: TFT.c TFT.h FONT.c FONT.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 2.6.3
